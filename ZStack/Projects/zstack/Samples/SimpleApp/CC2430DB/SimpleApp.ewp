# IAR project SimpleApp.ewp, settings and files
configuration SimpleControllerDB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCDefines: CC2430DB; HOLD_AUTO_START; SOFT_START; REFLECTOR; NV_INIT; xNV_RESTORE; xZTOOL_P2; xMT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2430DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430DB; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430.xcl
configuration SimpleControllerEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; HOLD_AUTO_START; SOFT_START; REFLECTOR; NV_INIT; xNV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\..\ZMAIN\TI2430DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2430EB; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\SRF03\SINGLE_CHIP; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC
configuration SimpleSwitchDB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430DB; NWK_AUTO_POLL; HOLD_AUTO_START; REFLECTOR; POWER_SAVING; NV_INIT; xNV_RESTORE; xZTOOL_P2; xMT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430pm.xcl
configuration SimpleSwitchEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; NWK_AUTO_POLL; HOLD_AUTO_START; REFLECTOR; POWER_SAVING; NV_INIT; xNV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430pm.xcl
configuration SimpleCollectorDB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430DB; HOLD_AUTO_START; SOFT_START; REFLECTOR; NV_INIT; xNV_RESTORE; ZTOOL_P2; MT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
configuration SimpleCollectorEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; HOLD_AUTO_START; SOFT_START; REFLECTOR; NV_INIT; xNV_RESTORE; ZTOOL_P1; MT_TASK; xMT_SAPI_FUNC; xMT_SAPI_CB_FUNC
  ICC8051.CCIncludePath2: as above
configuration SimpleSensorDB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430pm.xcl
configuration SimpleSensorEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430pm.xcl
  group App
    ../../../../../Components/stack/sapi/: sapi.c sapi.h
    ../Source/: SimpleApp.h SimpleCollector.c SimpleController.c SimpleSensor.c SimpleSwitch.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430DB/Config
    ../../../../../Components/hal/target/CC2430DB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430DB/Drivers
    ../../../../../Components/hal/target/CC2430DB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    ../../../../../Components/hal/target/CC2430DB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_types.h
  group HAL/Target/CC2430EB/Config
    ../../../../../Components/hal/target/CC2430EB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430EB/Drivers
    ../../../../../Components/hal/target/CC2430EB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430EB/Includes
    ../../../../../Components/hal/target/CC2430EB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT_AF.c MT_AF.h MT_NWK.c MT_NWK.h MT_SAPI.c MT_SAPI.h MT_ZDO.c MT_ZDO.h MTEL.c MTEL.h SPIMgr.c SPIMgr.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c OSAL_Nv.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL.h OSAL_Custom.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2430DB/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2430DB/: chipcon_banked_code_support.s51 chipcon_cexit.s51 chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
